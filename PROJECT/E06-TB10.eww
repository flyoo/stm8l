<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\E06-TB10.ewp</path>
  </project>
  <batchBuild/>
</workspace>


